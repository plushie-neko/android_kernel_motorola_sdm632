## drivers/input/fingerprint/sunwave_fp/Kconfig
```kconfig
config FINGERPRINT_SUNWAVE
	tristate "Sunwave Fingerprint"
	default y
	help
	  SUNWAVECORP Fingerprint
```
